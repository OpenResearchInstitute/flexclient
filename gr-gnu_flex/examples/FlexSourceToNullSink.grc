options:
  parameters:
    generate_options: qt_gui
    id: FlexRadioTest
    output_language: python
    title: FlexRadio Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gnu_flex_FlexSource_0
  id: gnu_flex_FlexSource
  parameters:
    ant: ANT1
    freq: '14.070'
    mode: USB
    serial: 1019-9534-6400-6018
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [gnu_flex_FlexSource_0, '0', qtgui_freq_sink_x_0, '0']
- [gnu_flex_FlexSource_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
